inherit devicetree

COMPATIBLE_MACHINE = "(rockchip-rv1106)"

SRC_URI:rockchip-rv1106 = "\
    file://rockchip-rv1106-luckfox-pico-max.dts \
"
